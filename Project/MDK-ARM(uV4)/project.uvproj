# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F429BI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,__RTX
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\RL-ARM\Driver;..\..\RL-ARM\Config;..\..\RL-ARM\RL-RTX\inc;..\..\RL-ARM\RL-RTX\portable;..\..\User\libapp;..\..\User\bsp\inc;..\..\User\bsp;..\..\User;..\..\SEGGER\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c includes.h RTX_Conf_CM.c
    ../../RL-ARM/Config/: Net_Config.c Net_Debug.c
  group APP
    ../../User/libapp/: app_tcpnet_lib.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c
    ../../User/bsp/src/: bsp_dwt.c bsp_led.c bsp_key.c bsp_ext_io.c bsp_uart_fifo.c bsp_rtt.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_fmc.c stm32f4xx_tim.c stm32f4xx_exti.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group RL-RTX/Source
    ../../RL-ARM/RL-RTX/src/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group RL-RTX/Ports
    ../../RL-ARM/RL-RTX/portable/: HAL_CM4.c rt_HAL_CM.h SVC_Table.s
  group RL-TCPnet/Lib
    ../../RL-ARM/RL-TCPnet/: TCPD_CM3.lib
  group RL-TCPnet/Driver
    ../../RL-ARM/Driver/: ETH_STM32F4xx.c ETH_STM32F4xx.h
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group SEGGER/RTT
    ../../SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
